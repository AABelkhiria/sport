## services/sensor_service/kconfig
```kconfig
config CONFIG_SENSOR_SERVICE_STACK_SIZE
    int "Config Sensor Service Stack Size"
    default 256
```
